# Repository PeiaLo/RS485C

File README.md:

# RS485_C — 多層樹狀傳感器網路

以 RS485 為傳輸骨幹的**多層樹狀**傳感器資料收集系統。頂層為 PC，往下經多層**中繼器**，末端接各類**傳感器模組**（溫度、壓力…）。最終用於**工廠端即時資料收集**：把傳統 PLC 資料轉為 PC 架構，客戶端可即時讀值、設定條件達成自動控制。

> 本專案接替並取代舊的 `R_C_MOD`。與 `ACL_001`（酒測儀）為完全獨立的兩個項目。

---

## 一分鐘理解

```
PC (頂層, 5V / 未來 Ethernet·WiFi)
 └─ RS485 bus (第1層)
     ├─ 中繼器 1  ── RS485 bus (第2層) ── 傳感器 / 更下層中繼器 …
     ├─ 中繼器 2
     └─ …(單一 bus 最多 64 台)
```

- 每台**中繼器**同時扮演兩個角色：對**上層**是 slave（被要求才回話），對**下層**是 master（主動輪詢）。
- 資料流是「**下層一直輪詢+暫存(cache)，上層要才給**」——把 PC 的讀取速度和下層 bus 速度解耦。
- 每台設備都靠**7 階指撥開關**定址；換機時預載好 JSON、撥同一位址即可直接替換。

## 文件導覽

| 文件 | 內容 |
|------|------|
| [docs/01_系統架構.md](docs/01_系統架構.md) | 整體拓樸、角色、資料流、cache 模型（含圖） |
| [docs/02_通訊協定.md](docs/02_通訊協定.md) | `\n`/`\r` byte 串流框架、輪詢時序、逾時、傳輸內容格式 |
| [docs/03_定址與指撥開關.md](docs/03_定址與指撥開關.md) | 7 階指撥、6 位址 + 1 功能、字串分層位址、層數判定 |
| [docs/04_軟體模組拆分.md](docs/04_軟體模組拆分.md) | 6 個可分頭開發的模組、介面契約、開發順序 |
| [docs/05_測試架構建議.md](docs/05_測試架構建議.md) | 用手上硬體（STM32/Nucleo/UNO/ESP32/MAX13487）分階段驗證 |
| [docs/06_設計決策與待確認.md](docs/06_設計決策與待確認.md) | 開放問題、風險、需要你拍板的地方 |
| [docs/07_採購清單.md](docs/07_採購清單.md) | 非陸製 BOM / 採購清單、手上硬體盤點 |
| [子專案/](子專案/00_拆分總覽.md) | **分對話開發用**：6 個模組的 kickoff brief，各含「貼到新對話的開場白」 |
| [schema/](schema/) | 設備 JSON schema 與範例（溫度、壓力） |
| [firmware/](firmware/) | 末端(Arduino) 與 中繼器(MicroPython) 韌體骨架 |
| [pc/](pc/) | PC 上位機骨架 |

## 技術棧

- **末端傳感器模組**：Arduino（C++），單純驅動 + 讀指撥 + 打包傳輸。
- **中繼器**：MicroPython（ESP32），善用 `list`/`dict` 做輪詢佇列與 cache。
- **PC 上位機**：Python（序列埠 / 未來 Ethernet），儀表板 + 規則引擎。
- **RS485 收發器**：MAX13487（AutoDirection，免 DE/RE 方向控制腳）。

## 目前狀態

規格已整理成文件（本次），韌體/軟體為骨架，尚未實作。建議先確定 [docs/06](docs/06_設計決策與待確認.md) 的待拍板項目，並先凍結 [docs/02 通訊協定](docs/02_通訊協定.md) 當作各模組共用契約，再分頭進行。

## KiCad design hardware/PCB/RS485_C_repeater.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C12: 100nF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6: 100uF 50V; CP_Radial_D8.0mm_P3.50mm
C7, C10, C13, C16: 10uF 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C8, C9, C11, C14, C15, C17: 1uF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D3, D6, D8, D9, D10, D11: ESD03V32D_LC; D_SOD-323_RECT
D4, D22, D23: SMAJ26CA; D_SMA
D5, D7, D14, D21: SS34; D_SMA
D13, D17, D18: SMAJ26A; D_SMA
D15, D19: ESD03V32D; D_SOD-323_RECT
D16: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1, F2, F3: PTC 0.5A 30V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
F4: PTC 1.1A 30V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1, J2, J3, J4: Conn_01x05; Molex_SL_171971-0005_1x05_P2.54mm_Vertical
J5: Barrel_Jack_Switch; BarrelJack_GCT_DCJ200-10-A_Horizontal
L1: 3.3uH; L_Changjiang_FXL0420
R1, R6, R7: 120ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4, R8, R9, R10: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder; not fitted
R5: 330ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11, R14: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12, R15, R17: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R13, R16: 0.1ohm 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW3: SW_DIP_x08 (CHS-08A, #8 unused); SW_DIP_SPSTx08_Slide_Copal_CHS-08A_W5.08mm_P1.27mm_JPin
U1: AQY212S; SO-4_4.4x4.3mm_P2.54mm_AQY212S_HandSolder
U2, U3, U4: MAX3485; SOIC127P600X175-8N
U5: RP2040supermini; RP2040_Super_Mini_Socket
U7, U9: INA180A3; SOT-23-5
U8, U12: SGM2225-3.3XK3G; SOT-89-3_SGM2225_Handsoldering_Engrave

Connections:
3V3: C1.1, C2.1, C3.1, C12.2, R2.2, R3.2, R4.2, R11.1, R16.2, U2.8 (VCC), U3.8 (VCC), U4.8 (VCC), U9.4 (-), U9.5 (V+)
+3V3: C4.1, C5.2, R13.2, U5.3V3, U7.4 (-), U7.5 (V+)
/A_3V3: C17.2, R17.2, U5.GP28
/A_MCU: C11.2, R15.2, U5.GP29
/DET: D9.2 (A2), R12.1, U5.GP7
/DIP0: SW3.7, U5.GP11
/DIP1: SW3.6, U5.GP12
/DIP2: SW3.5, U5.GP13
/DIP3: SW3.4, U5.GP14
/DIP4: SW3.3, U5.GP15
/DIP5: SW3.2, U5.GP26
/DIP6: SW3.1, U5.GP27
/DOWN__A: D6.1 (A1), J3.2, R2.1, R6.1, U2.6 (A)
/DOWN__A_S: D1.1 (A1), J4.2, R3.1, R7.1, U3.6 (A)
/DOWN__B: D10.2 (A2), J3.3, R6.2, R8.2, U2.7 (B)
/DOWN__B_S: D11.2 (A2), J4.3, R7.2, R10.2, U3.7 (B)
/RX1: U4.1 (RO), U5.GP1
/RX2: U2.1 (RO), U5.GP5
/RX3: U3.1 (RO), U5.GP10
/SWITCH1: U4.2 (~RE), U4.3 (DE), U5.GP2
/SWITCH2: U2.2 (~RE), U2.3 (DE), U5.GP6
/SWITCH3: U3.2 (~RE), U3.3 (DE), U5.GP9
/TERM__EN: R5.2, U5.GP3
/TX1: U4.4 (DI), U5.GP0
/TX2: U2.4 (DI), U5.GP4
/TX3: U3.4 (DI), U5.GP8
/UP_A: D3.1 (A1), J1.2, J2.2, R1.2, R4.1, U4.6 (A)
/UP_B: D8.2 (A2), J1.3, J2.3, R9.2, U1.3, U4.7 (B)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.1, D1.2 (A2), D3.2 (A2), D4.1 (A1), D6.2 (A2), D8.1 (A1), D9.1 (A1), D10.1 (A1), D11.1 (A1), D13.2 (A2), D15.2 (A2), D16.1 (K), D17.2 (A2), D18.2 (A2), D19.2 (A2), D22.1 (A1), D23.1 (A1), J1.4, J1.5, J2.4, J3.4, J3.5, J4.4, J4.5, J5.2, J5.3, R8.1, R9.1, R10.1, SW3.9, SW3.10, SW3.11, SW3.12, SW3.13, SW3.14, SW3.15, SW3.16, U1.2, U2.5 (GND), U3.5 (GND), U4.5 (GND), U5.GND, U7.2 (GND), U8.2 (GND), U9.2 (GND), U12.2 (GND)
unnamed: D5.2 (A), F1.1
unnamed: D7.2 (A), F2.1
unnamed: D13.1 (A1), F4.2, L1.1
unnamed: C6.1, D14.2 (A), L1.2, R14.2
unnamed: C9.1, C10.1, D15.1 (A1), R13.1, U7.3 (+), U8.1 (OUT)
unnamed: D16.2 (A), R14.1
unnamed: C15.1, C16.1, D19.1 (A1), R16.1, U9.3 (+), U12.1 (OUT)
unnamed: D21.2 (A), F3.1
unnamed: D21.1 (K), D23.2 (A2), J4.1
unnamed: D7.1 (K), D22.2 (A2), J3.1
unnamed: F4.1, J5.1
unnamed: J2.5, R11.2, R12.2
unnamed: R1.1, U1.4
unnamed: R5.1, U1.1
unnamed: R15.1, U7.1
unnamed: R17.1, U9.1
VBUS: D4.2 (A2), D14.1 (K), F1.2, F2.2, F3.2, J1.1, J2.1
VIN: C7.1, C8.1, C13.1, C14.1, D5.1 (K), D17.1 (A1), D18.1 (A1), U8.3 (IN), U12.3 (IN)

Notes on the sheet:
Per-DOWN-port PTC: a short in one branch only drops that branch. C9: 5V_SRC bulk (hot-plug hold-up), place near U2 / D10.
DIP0~6 IO採內建上拉

Board: 2 copper layers, 60.5 x 64.0 mm, 75 parts (42 on the bottom side), 47 nets.

Other parts of the board:
BRD1: Outline_M2; RS485_C_repeater_Outline_M2

## KiCad design hardware/PCB/RS485_C_terminal.kicad_pcb

Parts:
C3, C4: 100nF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder_RECT
C7, C10: 10uF 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder_RECT
C8, C9: 1uF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder_RECT
D3, D8: ESD03V32D_LC; D_SOD-323_RECT
D4: SMAJ26CA; D_SMA_RECT
D5: SS34; D_SMA_RECT
D15: ESD03V32D; D_SOD-323_RECT
D17: SMAJ26A; D_SMA_RECT
F1: PTC 0.5A 30V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder_RECT
J1: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical_RECT
J2: Conn_01x10; PinHeader_1x10_P2.54mm_Vertical_RECT
J8, J9: Conn_01x06; PinHeader_1x06_P2.54mm_Horizontal_RECT
Q1: 2N7002; SOT-23_RECT
Q3: 5n10; SOT-23_RECT
R4, R9: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT; not fitted
R5: 12KR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R11: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R12: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R13: 0.1ohm 1%; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R14: 120R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R15: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
SW1: SW_DIP_x06; SW_DIP_SPSTx06_Slide_KingTek_DSHP06TS_W7.62mm_P1.27mm_RECT
U1: SGM2225-3.3XK3G; SOT-89-3_SGM2225_Handsoldering_Engrave_RECT
U4: MAX3485; SOIC127P600X175-8N_RECT
U5: STM32F411CEU6 Pico; STM32F411_Pico_Socket_2x20_W17.78mm_RECT
U6: AQY212S; SO-4_4.4x4.3mm_P2.54mm_RECT

Connections:
+3V3: C3.1, C4.2, J2.1, R4.2, R11.1, R12.1, R13.2, U4.8 (VCC), U5.20 (3V3), U5.38 (3V3)
/A0: J1.4, J2.7
/A1: J1.3, J2.8
/A2: J1.2, J2.9
/A3: J1.1, J2.10
/DIP0: SW1.12, U5.30 (PA4)
/DIP1: SW1.11, U5.31 (PA5)
/DIP2: SW1.10, U5.32 (PA6)
/DIP3: SW1.9, U5.33 (PA7)
/DIP4: SW1.8, U5.34 (PB0)
/DIP5: SW1.7, U5.35 (PB1)
/NRST: Q1.3 (D), U5.25 (NRST)
/RST: J8.5, J9.5, Q1.1 (G), R15.2
/RX1: U4.1 (RO), U5.7 (PA10)
/SCL: J2.3, U5.14 (PB6)
/SDA: J2.4, U5.15 (PB7)
/SPARE_PA0: U5.26 (PA0)
/SPARE_PA1: U5.27 (PA1)
/SPARE_PA15: U5.10 (PA15)
/SPARE_PB3: U5.11 (PB3)
/SPARE_PB4: U5.12 (PB4)
/SPARE_PB5: U5.13 (PB5)
/SPARE_PB8: U5.16 (PB8)
/SPARE_PB9: U5.17 (PB9)
/SPARE_PB10: U5.37 (PB10)
/SPARE_PB12: U5.1 (PB12)
/SPARE_PB13: U5.2 (PB13)
/SPARE_PB14: U5.3 (PB14)
/SPARE_PB15: U5.4 (PB15)
/SPARE_PC13: U5.22 (PC13)
/SWITCH1: U4.2 (~RE), U4.3 (DE), U5.5 (PA8)
/TX1: U4.4 (DI), U5.6 (PA9)
/Tem_R_out: J9.6, Q3.1 (G), R11.2
/UP_A: D3.1 (A1), J8.2, J9.2, R4.1, R5.2, R14.2, U4.6 (A)
/UP_B: D8.2 (A2), J8.3, J9.3, R5.1, R9.2, U4.7 (B), U6.3
GND: C3.2, C4.1, C7.2, C8.2, C9.2, C10.2, D3.2 (A2), D4.1 (A1), D8.1 (A1), D15.2 (A2), D17.2 (A2), J2.2, J2.5, J8.4, J8.6, J9.4, Q1.2 (S), Q3.2 (S), R9.1, R15.1, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, U1.2 (GND), U4.5 (GND), U5.19 (GND), U5.39 (GND)
unnamed: D5.2 (A), F1.1
unnamed: C9.1, C10.1, D15.1 (A1), R13.1, U1.1 (OUT)
unnamed: Q3.3 (D), U6.2
unnamed: R12.2, U6.1
unnamed: R14.1, U6.4
VBUS: D4.2 (A2), F1.2, J8.1, J9.1
VIN: C7.1, C8.1, D5.1 (K), D17.1 (A1), U1.3 (IN)

Notes on the sheet:
Per-DOWN-port PTC: a short in one branch only drops that branch. C9: 5V_SRC bulk (hot-plug hold-up), place near U2 / D10.
DIP0~6 IO採內建上拉

Board: 2 copper layers, 52.6 x 68.7 mm, 33 parts (19 on the bottom side), 29 nets.

Other parts of the board:
BRD1: Outline_M3; RS485_C_terminal_Outline_M3

## KiCad design hardware/PCB/RS485_C_repeater_YJ.kicad_pcb

Parts:
C1, C2, C3, C4: 100nF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder_RECT
C6: 100uF 50V; CP_Radial_D8.0mm_P3.50mm_RECT
C7, C10: 10uF 50V; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder_RECT
C8, C9, C11, C12: 0.1uF 50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder_RECT
D1, D3, D6, D8, D10, D11: ESD03V32D_LC; D_SOD-323_RECT
D4, D22, D23: SMAJ26CA; D_SMA_RECT
D5, D7, D14: SS34; D_SMA_RECT
D13, D17: SMAJ26A; D_SMA_RECT
D15: ESD03V32D; D_SOD-323_RECT
D16: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder_RECT
F1, F2, F3: PTC 0.5A 30V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder_RECT
F4: PTC 3A 30V; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder_RECT
J1, J2, J3, J4: Conn_01x06; PinHeader_1x06_P2.54mm_Horizontal_RECT
J5: Barrel_Jack_Switch; BarrelJack_GCT_DCJ200-10-A_Horizontal_RECT
L1: 3.3uH; L_Changjiang_FXL0420_RECT
Q3: 5n10; SOT-23_RECT
R1, R6, R7: 120ohm; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R4: 12KR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R5: 20m ohm; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder_RECT
R11: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R12: 220R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R13, R15, R18, R19, R20, R21: 4K7R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R14: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
R22, R23, R24: 10KR; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder_RECT
SW2: SW_DIP_x06; SW_DIP_SPSTx06_Slide_Copal_CHS-06B_W7.62mm_P1.27mm_RECT
U1: INA180A3; SOT-23-5_RECT
U2, U3, U4: MAX3485; SOIC127P600X175-8N_RECT
U5: RP2040supermini; RP2040_Super_Mini_Socket_RECT
U6: AQY212S; SO-4_4.4x4.3mm_P2.54mm_RECT
U7: SGM2225-3.3XK3G; SOT-89-3_SGM2225_Handsoldering_Engrave_RECT

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C9.1, C10.1, D15.1 (A1), R11.1, R12.1, R13.1, R18.1, R20.1, U1.5 (V+), U2.8 (VCC), U3.8 (VCC), U4.8 (VCC), U5.3V3, U7.1 (OUT)
/A_3V3: C12.1, U1.1, U5.GP28
/DIP0: SW2.12, U5.GP11
/DIP1: SW2.11, U5.GP12
/DIP2: SW2.10, U5.GP13
/DIP3: SW2.9, U5.GP14
/DIP4: SW2.8, U5.GP15
/DIP5: SW2.7, U5.GP26
/DOWN__A: D6.1 (A1), J3.2, R6.1, R18.2, U2.6 (A)
/DOWN__A_S: D1.1 (A1), J4.2, R7.1, R20.2, U3.6 (A)
/DOWN__B: D10.2 (A2), J3.3, R6.2, R19.1, U2.7 (B)
/DOWN__B_S: D11.2 (A2), J4.3, R7.2, R21.1, U3.7 (B)
/RST: J1.5, J2.5, U5.GP29
/RST_2: J3.5, U5.GP6
/RST_3: J4.5, U5.GP7
/RX1: U4.1 (RO), U5.GP1
/RX2: U2.1 (RO), U5.GP5
/RX3: U3.1 (RO), U5.GP10
/SWITCH1: R22.2, U4.2 (~RE), U4.3 (DE)
/SWITCH2: R23.2, U2.2 (~RE), U2.3 (DE)
/SWITCH3: R24.2, U3.2 (~RE), U3.3 (DE)
/TX1: U4.4 (DI), U5.GP0
/TX2: U2.4 (DI), U5.GP4
/TX3: U3.4 (DI), U5.GP8
/Tem_R_OUT: J2.6, Q3.1 (G), R11.2
/UP_A: D3.1 (A1), J1.2, J2.2, R1.2, R4.2, R13.2, U4.6 (A)
/UP_B: D8.2 (A2), J1.3, J2.3, R4.1, R15.1, U4.7 (B), U6.3
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C12.2, D1.2 (A2), D3.2 (A2), D4.1 (A1), D6.2 (A2), D8.1 (A1), D10.1 (A1), D11.1 (A1), D13.2 (A2), D15.2 (A2), D16.1 (K), D17.2 (A2), D22.1 (A1), D23.1 (A1), J1.4, J1.6, J2.4, J3.4, J4.4, J5.2, J5.3, Q3.2 (S), R15.2, R19.2, R21.2, SW2.1, SW2.2, SW2.3, SW2.4, SW2.5, SW2.6, U1.2 (GND), U2.5 (GND), U3.5 (GND), U4.5 (GND), U5.GND, U7.2 (GND)
unnamed: C11.2, D5.1 (K), R5.1, U1.3 (+)
unnamed: D7.2 (A), F2.1
unnamed: D13.1 (A1), F4.2, L1.1
unnamed: C6.1, D14.2 (A), L1.2, R14.2
unnamed: D16.2 (A), R14.1
unnamed: D7.1 (K), D22.2 (A2), J3.1
unnamed: D23.2 (A2), F3.1, J4.1
unnamed: F4.1, J5.1
unnamed: Q3.3 (D), U6.2
unnamed: R1.1, U6.4
unnamed: R12.2, U6.1
unnamed: R22.1, U5.GP2
unnamed: R23.1, U5.GP3
unnamed: R24.1, U5.GP9
unnamed: C11.1, F1.1, R5.2, U1.4 (-)
VBUS: D4.2 (A2), D5.2 (A), D14.1 (K), F2.2, F3.2, J1.1, J2.1
VIN: C7.1, C8.1, D17.1 (A1), F1.2, U7.3 (IN)

Notes on the sheet:
Per-DOWN-port PTC: a short in one branch only drops that branch. C9: 5V_SRC bulk (hot-plug hold-up), place near U2 / D10.
DIP0~6 IO採內建上拉
利用WDT強制RESET
